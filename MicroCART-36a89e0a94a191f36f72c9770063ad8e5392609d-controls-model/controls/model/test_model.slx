simulink model "test_model"  (R2016b)
settings: Solver=VariableStepAuto  StartTime=0.0  StopTime=runtime  RelTol=1e-3
InitFcn:
  | clear mex
  | delete test_model_sfun.mexw64
values from neighbouring files (symbols this model uses):
  g = 9.81    [modelParameters.m]
  height_controlled_o = (((Rm*If +      + (((omega0_o * 2 * Rm * Kv * Kq       * Kd + 1)^2) - 1)/(4* Rm*Kv^2*Kq      *Kd))/Vb)*(Pmax- Pmin)+Pmin)    [modelParameters.m]
  If = 0.511    [modelParameters.m]
  Jreq = 4.2012e-05    [modelParameters.m]
  Jxx = 0.0130    (= 0.013)    [modelParameters.m]
  Jyy = 0.0140    (= 0.014)    [modelParameters.m]
  Jzz = 0.0285    [modelParameters.m]
  Kd = 1.0317e-7    (= 1.0317e-07)    [modelParameters.m]
  Kq = 96.3422    [modelParameters.m]
  Kt = 8.6519e-6    (= 8.6519e-06)    [modelParameters.m]
  Kv = 96.3422    [modelParameters.m]
  m = 1.244    [modelParameters.m]
  omega0_o = (-1 + sqrt(1 - 4*Rm*Kv*Kq*Kd*( Kv*Rm*If - Kv*Vb_eff_0))) / (2*Rm*Kv*Kq*Kd)    [modelParameters.m]
  omega1_o = (-1 + sqrt(1 - 4*Rm*Kv*Kq*Kd*( Kv*Rm*If - Kv*Vb_eff_1))) / (2*Rm*Kv*Kq*Kd)    [modelParameters.m]
  omega2_o = (-1 + sqrt(1 - 4*Rm*Kv*Kq*Kd*( Kv*Rm*If - Kv*Vb_eff_2))) / (2*Rm*Kv*Kq*Kd)    [modelParameters.m]
  omega3_o = (-1 + sqrt(1 - 4*Rm*Kv*Kq*Kd*( Kv*Rm*If - Kv*Vb_eff_3))) / (2*Rm*Kv*Kq*Kd)    [modelParameters.m]
  pitch_o = pitch_value(1)    [modelParameters.m]
  pitchrate_o = pitchrate_value(1)    [modelParameters.m]
  Pmax = 2e5    (= 200000)    [modelParameters.m]
  Pmin = 1e5    (= 100000)    [modelParameters.m]
  rhx = 0.16    [modelParameters.m]
  rhy = 0.16    [modelParameters.m]
  rhz = 0.03    [modelParameters.m]
  Rm = 0.2308    [modelParameters.m]
  roll_o = roll_value(1)    [modelParameters.m]
  rollrate_o = rollrate_value(1)    [modelParameters.m]
  Tc = 0.04    [modelParameters.m]
  Tq = 0.005    [modelParameters.m]
  Vb = 11.1    [modelParameters.m]
  x_controlled_o = 0    [modelParameters.m]
  x_o = x_position(1)    [modelParameters.m]
  x_vel_o = (x_position(2) - x_position(1)) / (time(2) - time(1))    [modelParameters.m]
  y_controlled_o = 0    [modelParameters.m]
  y_o = y_position(1)    [modelParameters.m]
  y_vel_o = (y_position(2) - y_position(1)) / (time(2) - time(1))    [modelParameters.m]
  yaw_controlled_o = 0    [modelParameters.m]
  yaw_o = yaw_value(1)    [modelParameters.m]
  yawrate_o = yawrate_value(1)    [modelParameters.m]
  z_o = z_position(1)    [modelParameters.m]
  z_vel_o = (z_position(2) - z_position(1)) / (time(2) - time(1))    [modelParameters.m]
undefined symbols (not defined in the file or in its folder): DiscIntNeverNeededParam
libraries: simulink x21, vrlib x2
(part 3 of 3)

== matlab function test_model/Actuation/Aeb














 ==
function euler_rates = angular_body_earth_conversion(B_omega, euler_angles)

phi = euler_angles(1);
theta = euler_angles(2);

Aeb = [1,  sin(phi)*tan(theta), cos(phi)*tan(theta); ...
       0,      cos(phi)       ,        -sin(phi)   ; ...
       0,  sin(phi)/cos(theta), cos(phi)/cos(theta)];

   
euler_rates = Aeb * B_omega;

== matlab function test_model/Actuation/Lbe

















 ==
function [B_Fg, B_g]  = linear_earth_body_conversion(E_Fg, euler_angles, m)

phi = euler_angles(1);
theta = euler_angles(2);
psi = euler_angles(3);

Lbe = [             cos(theta)*cos(psi)              ,          cos(theta)*sin(psi)                  ,     -sin(theta)    ; ...
       sin(phi)*sin(theta)*cos(psi)-cos(phi)*sin(psi), sin(phi)*sin(theta)*sin(psi)+cos(phi)*cos(psi), sin(phi)*cos(theta); ...
       cos(phi)*sin(theta)*cos(psi)+sin(phi)*sin(psi), cos(phi)*sin(theta)*sin(psi)-sin(phi)*cos(psi), cos(phi)*cos(theta)];

B_Fg = Lbe * E_Fg;

B_g = B_Fg/m;

== matlab function test_model/     Sensors   /Complimentary Filter







 ==
%function euler_angles_IMU  = complimentaryFilter(accel_pitch, accel_roll, euler_angles_gyro, prev_euler_angles_IMU)
function euler_angles_IMU  = complimentaryFilter(accel_pitch, accel_roll, euler_angles_gyro)

% LOOP_TIME = 5*10^-3;
% 
% prev_phi = prev_euler_angles_IMU(1);
% prev_theta = prev_euler_angles_IMU(2);
% 
% phi_dot_gyro = euler_angles_gyro(1);
% theta_dot_gyro = euler_angles_gyro(2);

% phi = 0.98 * ( prev_phi + phi_dot_gyro * LOOP_TIME ) + 0.02 * accel_roll;
% theta = 0.98 * ( prev_theta + theta_dot_gyro * LOOP_TIME) + 0.02 * accel_pitch;
k_gyro = 1; 
k_accel = 1-k_gyro; 

phi = k_gyro * ( euler_angles_gyro(1) ) + k_accel * accel_roll;
theta = k_gyro * ( euler_angles_gyro(2) ) + k_accel * accel_pitch;

euler_angles_IMU = [phi; theta];

== matlab function test_model/     Sensors   /IMU





/






 ==
function [accelReading,gyroReading] = idealIMU(B_vo_dot, B_vo, B_Omega, B_g, r_oc, g)
%#codegen

a = B_vo_dot + cross(B_Omega,B_vo) ; % body frame acceleration 

accelReading = (a - B_g)/g ; % accelerometer reading (ideal)

gyroReading = B_Omega ; % gyroscope reading (ideal) 

end

== matlab function test_model/     Sensors   /3D Graphical Simulation/MATLAB Function ==
function y = eigenaxis_ucart(u)


if abs(u(1))< 0.0001
    u(1) = 0.0001;
end

if abs(u(2))< 0.0001
    u(2) = 0.0001;
end

if abs(u(3))< 0.0001
    u(3) = 0.0001;
end

u = [ -u(1); -u(2); u(3) ];% [Pitch, Yaw, Roll] 

C11 = cos(u(2))*cos(u(3));
C12 = cos(u(2))*sin(u(3));
C13 = -sin(u(2));
C21 = sin(u(1))*sin(u(2))*cos(u(3))-cos(u(1))*sin(u(3));
C22 = sin(u(1))*sin(u(2))*sin(u(3))+cos(u(1))*cos(u(3));
C23 = sin(u(1))*cos(u(2));
C31 = cos(u(1))*sin(u(2))*cos(u(3))+sin(u(1))*sin(u(3));
C32 = cos(u(1))*sin(u(2))*sin(u(3))-sin(u(1))*cos(u(3));
C33 = cos(u(1))*cos(u(2));
    
theta = acos(0.5*(C11+C22+C33-1));

e = [C23-C32; C31-C13; C12-C21]/(2*sin(theta));
    
y = [e; theta];

== matlab function test_model/     Sensors   /Aeb









 ==
function euler_rates_IMU = angular_body_earth_conversion(gyro_reading, euler_angles_IMU)

phi = euler_angles_IMU(1);
theta = euler_angles_IMU(2);

Aeb = [1, sin(phi)*tan(theta), cos(phi)*tan(theta); ...
       0,     cos(phi)       ,        -sin(phi)   ; ...
       0,  sin(phi)/cos(theta), cos(phi)/cos(theta)];

   
euler_rates_IMU = Aeb * gyro_reading;

== matlab function test_model/     Sensors   /Calculate Pitch and Roll











1 ==
function [accel_pitch, accel_roll] = getPitchAndRoll(accel_reading, accel_roll_prev)

mag = norm(accel_reading);

x_accel = accel_reading(1)/mag;
y_accel = accel_reading(2)/mag;
z_accel = accel_reading(3)/mag;

accel_pitch = atan(x_accel/sqrt(y_accel^2 + z_accel^2));
%unwrapped_pitch = unwrap([accel_pitch_prev accel_pitch]);
%accel_pitch = unwrapped_pitch(2);

accel_roll = atan2( -y_accel,(sign(-z_accel)*sqrt(z_accel^2 + (1/100)*x_accel^2)) );
unwrapped_roll = unwrap([accel_roll_prev accel_roll]);
accel_roll = unwrapped_roll(2);

== matlab function test_model/Control System/Signal Mixer ==
function P  = signal_mixer(height_controlled, y_controlled, x_controlled, yaw_controlled)

controller_outputs = [ height_controlled; x_controlled; y_controlled; yaw_controlled ];
signal_mixer = [ 1, -1, -1, -1; ... 
                 1,  1, -1,  1; ...
                 1, -1,  1,  1; ...
                 1,  1,  1, -1 ];

% signal_mixer = [ 1,  1, -1, -1; ... 
%                  1, -1, -1,  1; ...
%                  1,  1,  1,  1; ...
%                  1, -1,  1, -1 ];
             
P = signal_mixer * controller_outputs;

== matlab function test_model/Control System/MATLAB Function1 ==
function [z_corr, y_cor, x_corr, yaw_corr, pid_y_out, pid_roll_out] = c_controller(set_x, set_y, set_z, set_yaw, ...
    cur_x, cur_y, cur_z, ...
    cur_phi, cur_theta, cur_psi, ...
    cur_phi_d, cur_theta_d, cur_psi_d, vrpn_id, Tc)

out_z = -1;
out_y = -1;
out_x = -1;
out_yaw = -1;
c_pid_y = -1;
c_pid_roll = -1;

coder.ceval('c_controller', vrpn_id, Tc, set_x, set_y, set_z, set_yaw, ...
                    cur_x, cur_y, cur_z, ...
                    cur_phi, cur_theta, cur_psi, ...
                    cur_phi_d, cur_theta_d, cur_psi_d, ...
                    coder.wref(out_z), coder.wref(out_y), coder.wref(out_x), coder.wref(out_yaw), ...
                    coder.wref(c_pid_y), coder.wref(c_pid_roll));

z_corr = out_z;
y_cor = out_y;
x_corr = out_x;
pid_y_out = c_pid_y;
pid_roll_out = c_pid_roll;
yaw_corr = out_yaw;
